options:
  parameters:
    generate_options: qt_gui
    id: Practica1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '30000'
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '5'
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1000'
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (0.000200113940055307,0.00014440624344565,6.0975847227686e-05,-5.46014036076452e-05,-0.000204878638034827,-0.000389693367393234,-0.000605515156760819,-0.000845073566614587,-0.0010973383739139,-0.00134789985377776,-0.00157976454509979,-0.00177454265752001,-0.00191395970878005,-0.0019815811483561,-0.00196459984198519,-0.00185550816670283,-0.00165346461180738,-0.00136517340569841,-0.00100512675009838,-0.000595111797051836,-0.000162954497343012,0.000259446975251974,0.000638664251813284,0.000942647135539775,0.00114373266738037,0.00122145825287278,0.00116488206190405,0.000974146570954971,0.00066108481999859,0.000248758224861699,-0.000230079146238615,-0.000735483266907812,-0.00122357844230086,-0.00165027403648616,-0.00197508611570448,-0.00216469078181463,-0.00219585604870782,-0.00205745754562383,-0.00175137427968215,-0.0012921745930451,-0.000705627109905991,-2.61934024829646e-05,0.00070623499746316,0.00145001447050304,0.00216545975231623,0.00281820467003965,0.00338187295196471,0.00383979868501191,0.00418564482251067,0.00442289372035233,0.00456331145220758,0.00462460249040075,0.00462755938569609,0.00459306258315741,0.00453929232767813,0.004479477155928,0.00442042691696455,0.00436199292969834,0.00429747785415991,0.00421489902357234,0.00409890683677757,0.00393308722826981,0.00370234270831022,0.00339505297906624,0.00300476087828233,0.00253120439372679,0.00198060893859365,0.00136525227827014,0.000702403922614835,1.28100182091053e-05,-0.000681064038721584,-0.00135681126241814,-0.0019936793569625,-0.00257382906809958,-0.00308315947531173,-0.00351167272538253,-0.00385341439399119,-0.00410607663770059,-0.0042703834067176,-0.00434938741896758,-0.00434779807845636,-0.00427143194907586,-0.00412683895989059,-0.00392111552130566,-0.00366187730953036,-0.0033573354765104,-0.00301640424149474,-0.00264876657616781,-0.00226483700370197,-0.00187558340094141,-0.00149219871740396,-0.00112564356975896,-0.0007861065955804,-0.000482446835148157,-0.000221688231169623,-8.62951249527386e-06,0.000154385581516236,0.000267519242406115,0.000333322808098435,0.00035649026945816,0.000343538743343811,0.000302478817049617,0.000242529559864927,0.000173911403208241,0.000107718621780369,5.58376572181464e-05,3.08451706996274e-05,4.57977481643512e-05,0.000113819682155407,0.00024740994513233,0.000457424888816178,0.000751746312314292,0.00113370886396827,0.00160042705724378,0.00214121969459216,0.00273636736843054,0.00335644776873558,0.00396246788160763,0.00450695049003691,0.00493603863219083,0.00519256500348532,0.00521990726839201,0.0049663312853954,0.00438942952289843,0.00346020705160275,0.00216636412352442,0.000514378261624767,-0.00146990153061499,-0.00374227970146096,-0.00624280355345915,-0.00889966908468072,-0.011634020010416,-0.0143650850657392,-0.0170150323591609,-0.0195129330883569,-0.0217973250122449,-0.0238170419592341,-0.0255302112032664,-0.0269015879021039,-0.0278986605838057,-0.02848718728123,-0.0286269743452287,-0.0282687624938693,-0.0273530217634721,-0.0258112770760641,-0.0235703024307024,-0.0205591618237885,-0.0167186782761926,-0.0120125259399355,-0.00643881383622241,-4.08095522999134e-05,0.00708462603698658,0.0147822342202627,0.0228382690693347,0.0309858004449588,0.0389155638333789,0.0462919267831338,0.0527729592536368,0.0580330828669268,0.0617863954271837,0.0638085732164018,0.0639552760984739,0.0621752266453203,0.0585165853211623,0.0531258552668581,0.0462392581455556,0.0381672496627283,0.0292735089235518,0.0199502651629946,0.0105921595065571,0.00157094204776767,-0.00678683334513939,-0.0142173133175452,-0.0205307812255084,-0.0256164065654331,-0.029440374337847,-0.0320381056774195,-0.0335018148790261,-0.0339650166631736,-0.0335857688012085,-0.0325304016716887,-0.0309592652392753,-0.0290156538424294,-0.0268186037051668,-0.0244597583970689,-0.0220040240715717,-0.019493341676814,-0.01695262606752,-0.0143967832745243,-0.0118377199238216,-0.00929038872599876,-0.00677714321102035,-0.00432996665539077,-0.00199045400333611,0.000192277376209051,0.00216532498718682,0.00387678977280782,0.00528093198959948,0.00634301143696893,0.00704320975104985,0.00737917611053177,0.00736692228930839,0.00703999422413469,0.00644704153819311,0.00564807336214827,0.00470981290846006,0.00370063517668515,0.00268558875702079,0.00172196670022661,0.000855810589867568,0.000119617834971474,-0.000468611302221438,-0.000904988600115778,-0.00119814515551548,-0.00136666892838772,-0.00143588749936694,-0.00143435239413941,-0.00139038565461738,-0.00132901879431223,-0.00126959416845431,-0.00122421674357519,-0.00119714933804521,-0.00118514624652248,-0.0011786280822912,-0.00116352295108406,-0.00112354232075811,-0.00104262863600241,-0.000907307820844498,-0.000708702630835667,-0.00044400905976486,-0.000117302041487417,0.000260388889132944,0.000671716879054482,0.0010942808147187,0.00150237059728153,0.00186901370169647,0.00216812637952211,0.00237657854930063,0.00247600547966716,0.00245423670562643,0.00230625699474962,0.00203465933400678,0.00164959057783041,0.00116822309148751,0.000613809071636559,1.43888610348729e-05,-0.000598767410252708,-0.00119290138628019,-0.00173560499422722,-0.00219666663679108,-0.00254983234919323,-0.002774386464747,-0.00285645650209421,-0.0027899526416946,-0.00257706551620124,-0.0022282682706107,-0.0017617996140247,-0.00120264187897633,-0.00058104843132771,6.92863720027537e-05,0.000713288917776045,0.00131665206623983,0.00184790895369461,0.00228028570805822,0.00259320487946901,0.00277334383508756,0.00281519216230567,0.00272109445762555,0.00250080508512676,0.00217061574221539,0.00175214240481555,0.00127087423226119,0.000754593274143314,0.000231771187801268,-0.000269960953290867,-0.000725189579236312,-0.00111188182810547,-0.00141229608052683,-0.00161362194262253,-0.00170835036178683,-0.00169438886530371,-0.00157494584872142,-0.00135821122355096,-0.0010568594338002,-0.000687396712021385,-0.000269369952962888,0.000175547670451488,0.000624577161148594,0.00105493565827858,0.00144498309565059,0.00177536158251836,0.00203006061930671,0.00219733045655403,0.00227036297398893,0.00224766724959697,0.00213308670148552,0.00193543536512732,0.00166776930435413,0.00134635022736661,0.00098939584653526,0.000615739105620484,0.000243530967304695,-0.000110883953690052,-0.000433813133236578,-0.00071471618882065,-0.000946340529204577,-0.00112452450964548,-0.00124774485241352,-0.00131651688437315,-0.00133276959788013,-0.00129931038863656,-0.00121946778252208,-0.00109695910240497,-0.00093598102317022,-0.00074147288542198,-0.000519463971809334,-0.000277393643661564,-2.42915035434386e-05,0.000229275676684204,0.000471545570067621,0.000690195582914319,0.000873222944685021,0.00100997212678488,0.00109217741355436,0.0011148739153428,0.00107703891423008,0.000981856308384825,0.00083654554440856,0.000651755383136464,0.000440583079864948,0.00021733187677689,-3.84376192795978e-06,-0.000210240309046131,-0.000391697532860018,-0.000541353110097968,-0.000655977704628723,-0.000735864810318614,-0.000784307569758338,-0.000806746558863339,-0.000809711505778639,-0.000799701576074277,-0.000782151289588166,-0.000760613047893783,-0.000736255640929428,-0.000707735649391503,-0.000671451004216344,-0.000622138947095871,-0.000553739614645574,-0.000460415766046001,-0.000337601706333363,-0.000182951568443384,2.93140528051335e-06,0.000216078708203566,0.000449113445434634,0.000691599561689357,0.000930759952194605,0.00115249931844711,0.00134263321046672,0.00148820009320608,0.00157872115295497,0.00160727439899878,0.00157126551392052,0.00147280651625828,0.00131865192835482,0.00111968700211263,0.000890009133068063,0.000645687084998013,0.000403318410569653,0.000178529448123903,-1.54285227532038e-05,-0.000168840609757943,-0.000276324370768662,-0.000337175950909794,-0.000355230466722938,-0.000338255067539062,-0.000296946410434622,-0.000243649973994171,-0.000190950658820265,-0.000150297967769344,-0.00013082252282827,-0.00013847433148929,-0.000175570458647141,-0.000240786383614842,-0.000329568676776907,-0.000434894514827858,-0.000548263028283917,-0.000660779804225844,-0.000764191753833512,-0.000851744787764557,-0.00091876831407227,-0.000962933236944845,-0.00098417731474084,-0.000984336617130362,-0.000966558410823202,-0.000934594770273242,-0.000892085365289789,-0.000841932256770222,-0.000785851120280141,-0.000724155524088022,-0.000655797893285283,-0.000578656896065228,-0.000490030079143107,-0.000387265770826593,-0.000268451728684139,-0.000133070923738048,1.74625009632871e-05,0.000179462224437982,0.00034687905507884,0.000511490098729325,0.000663367895761964,0.000791599396626976,0.000885196638735452,0.000934118158722998,0.000930305029337397,0.000868629670359972,0.000747659934844116,0.000570154983610081,0.000343231677153832,7.81683950210078e-05,-0.000210155368335575,-0.00050415342664608,-0.000784701552029866,-0.00103249555678032,-0.0012294954194788,-0.00136034120110995,-0.00141362418191808,-0.00138290327944322,-0.00126737236765999,-0.0010721081550569,-0.000807859805720919,-0.000490378813338086,-0.000139328216291135,0.000223149396621144,0.000574089745308699,0.000891448415555976,0.00115577046582212,0.00135163537102365,0.00146874501895209,0.00150255892756105,0.00145442922660713,0.00133124196154906,0.00114462342492924,0.000909813077199756,0.000644332231029026,0.000366586711624726,9.45321149946576e-05,-0.000155494740128732,-0.000369709295771288,-0.00053754618217212,-0.000652061273133592,-0.00071009426106648,-0.000712228726518318,-0.000662586472718498,-0.00056848393572358,-0.000439965597953946,-0.000289217912628573,-0.000129861925453846,2.38736148924404e-05,0.000158083920441791,0.000260189624547326,0.00031994954907837,0.000330404628144854,0.000288658217124775,0.000196394681611025,6.00486576766337e-05,-0.000109437898902251,-0.00029729663644698,-0.000486031785464383,-0.000656868366405427,-0.000791434828124995,-0.00087352847261151,-0.00089078973818938,-0.000836107609818895,-0.000708594894797663,-0.000514008147436457,-0.000264539417700702,2.20297035334809e-05,0.000323754066257173,0.000616409862158625,0.000875665056447749,0.00107932699405464,0.00120944537188515,0.0012540586195454,0.00120840408414644,0.0010754640068577,0.000865784758857321,0.000596579320693651,0.000290194929476278,-2.79083720989017e-05,-0.000331473560463382,-0.000595833044339481,-0.000800135741713615,-0.000929202231202293,-0.000974834239050699,-0.000936460805160161,-0.000821070627190273,-0.00064245097245292,-0.00041982052691891,-0.000175999601216166,6.46993071041835e-05,0.000278657935879551,0.000445014320352873,0.000547420131925104,0.000575350230604671,0.000524870118216957,0.000398821440769861,0.000206439942483352,-3.75311143647018e-05,-0.00031413046880423,-0.000601744110619096,-0.000877807673633276,-0.00112050983655976,-0.00131037494819889,-0.00143162623195963,-0.00147325897798352,-0.00142978200796887,-0.00130161166391138,-0.00109512281942016,-0.000822374528587883,-0.000500534153810298,-0.000151024995074253,0.000201578367971949,0.000530882040525444,0.000810201510776408,0.00101424401558938,0.00112088183742027,0.00111292877379846,0.000979805462267806,0.000718956446769523,0.000336868781247193,-0.000150455861270864,-0.000717702093640534,-0.00133119877510039,-0.00195065612725254,-0.00253162756123051,-0.00302855853646947,-0.00339820496487745,-0.0036031383443728,-0.00361501438915463,-0.00341727466375707,-0.00300698127326405,-0.00239555305113177,-0.00160827287850353,-0.000682559851879655,0.000334866863687889,0.00139167968809686,0.00243413457284567,0.00341134350972449,0.00427919128765248,0.0050034956096962,0.00556209431275054,0.00594566766439296,0.00615725225056248,0.00621055683142932,0.00612732966980774,0.00593413290763775,0.00565893861598793,0.00532796558472808,0.0049631256860164,0.00458035129566497,0.00418894495306634,0.00379194794829712,0.00338738645500838,0.00297014154515153,0.00253411811645309,0.00207436618420412,0.00158883723750777,0.00107953194928157,0.000552900655026277,1.94777737880583e-05,-0.00050715253094071,-0.00101186650962004,-0.00147973173412294,-0.0018976826033556,-0.00225588551782432,-0.00254859743433337,-0.00277440752183439,-0.00293585140690124,-0.00303848584216313,-0.00308959393941091,-0.00309674536079911,-0.00306645430745009,-0.00300315840990605,-0.00290868706393928,-0.00278230697800463,-0.00262133830455923,-0.00242224141327084,-0.002181996673039,-0.00189954966114661,-0.00157707978036066,-0.00122087350458641,-0.00084164061228082,-0.000454193726386508,-7.65054091797046e-05,0.000271751531375648,0.000570999762195589,0.000803660531117262,0.000955921332815731,0.00101914603588479,0.000990757021563957,0.000874493090112181,0.000680032323352707,0.00042205320907566,0.000118878195417873,-0.000209108255661832,-0.000541056338675597,-0.000857064034812074,-0.00113924983178897,-0.00137239209911163,-0.00154411916398431,-0.00164471269275296,-0.00166665514137621,-0.00160409887308398,-0.00145245174605174,-0.00120825721389351,-0.000869496831249202,-0.000436365322219926,8.75263353928812e-05,0.000693661819343762,0.00136707068470514,0.00208500214203636,0.00281611913295585,0.00352047890157941,0.00415048806098566,0.00465290322658452,0.00497180745870106,0.00505234790751106,0.00484489331414013,0.00430918238940497,0.00341800199821174,0.00215996645118137,0.000541065526716437,-0.00141520142291088,-0.00366910437169542,-0.00616718238973007,-0.00884560230389139,-0.0116338933899515,-0.0144585249748993,-0.0172458261184419,-0.0199238610871909,-0.0224230578876758,-0.0246756147849688,-0.0266139481528965,-0.0281686570694453,-0.0292666304041134,-0.0298299825436363,-0.029776457942545,-0.0290217907233053,-0.0274842576839257,-0.0250913498495603,-0.0217881487447599,-0.0175466744825903,-0.0123752191101155,-0.00632652961162467,0.000496312211912293,0.00793733994950923,0.0157892479831156,0.0237994239882261,0.0316804154456427,0.0391243099778233,0.0458200737179525,0.051472538698035,0.0558215012803229,0.0586593167041194,0.0598454602279961,0.0593167650467672,0.0570924159785637,0.0532732369457488,0.0480353117558661,0.0416184706623234,0.0343106111564754,0.0264291594281126,0.0183011893388058,0.0102437827949086,0.0025461379148262,-0.00454527790342481,-0.0108375493521902,-0.0161975183850494,-0.020553207220969,-0.0238907120302346,-0.0262471947861231,-0.0277008984400871,-0.0283593068585507,-0.0283466517990368,-0.0277919320512963,-0.0268184637457018,-0.0255357453097305,-0.0240341236706179,-0.0223824235290391,-0.0206283840736866,-0.0188014703667472,-0.0169174168939881,-0.0149837366849588,-0.01300539860493,-0.010989934566064,-0.00895137424491311,-0.00691259649717296,-0.00490590847774144,-0.00297188868936591,-0.00115673387993185,0.000491488562904523,0.00192717555283799,0.00311156128739237,0.00401660031414606,0.00462791111129879,0.00494645427284253,0.0049887726341439,0.00478578558767873,0.00438028806301383,0.00382343921096936,0.00317062291559971,0.00247711268372033,0.00179397371924328,0.00116458755109335,0.000622097426520878,0.000187958072748691,-0.000128353824358517,-0.000328536620000608,-0.000423744239322098,-0.000432206449424607,-0.000376490622279883,-0.000280715273710459,-0.000167999325382405,-5.83758261710487e-05,3.26763470974911e-05,9.5014064282873e-05,0.000123939718458566,0.000119727093388047,8.67059336303619e-05,3.20795343989823e-05,-3.53433579500899e-05,-0.000106337485146619,-0.000172241834604455,-0.000225652229030478,-0.000260800428733878,-0.00027364667660188,-0.000261754942167939,-0.000224046587465505,-0.000160535299554573,-7.21334696783448e-05,3.94095072156589e-05,0.000171417716026519,0.000320073797763178,0.000480145168840683,0.000644746645305354,0.000805245686813089,0.000951406855481793,0.00107184247367549,0.00115479074382326,0.00118918732369779,0.00116593977370465,0.00107926514384376,0.000927917282804376,0.000716118501610945,0.000454023664107593,0.000157584059258077,-0.000152259476912804,-0.000451046137730292,-0.000712833467348291,-0.000912628223478097,-0.00102896642023371,-0.00104635749577855,-0.000957299065952887,-0.000763597256286244,-0.000476792140388799,-0.000117582283627401,0.000285743847167699,0.000699742803719737,0.00108888183321571,0.00141891616484863,0.00166021243860604,0.00179065104707088,0.00179778425839473,0.00168001187683794,0.00144665104415521,0.00111690650202556,0.000717875060614961,0.000281826429259892,-0.000156921878730537,-0.000565184137095504,-0.00091380010730142,-0.00117995488341761,-0.00134872173149875,-0.00141372893705112,-0.00137696015637244,-0.00124779586061612,-0.00104147893156042,-0.000777232222906244,-0.000476266915363992,-0.000159899878269297,0.000152047493265835,0.000442457847803946,0.000697688883863179,0.00090792245901972,0.00106715436215933,0.00117291545547902,0.00122582304999541,0.00122905193407059,0.00118779265948992,0.00110873730474617,0.000999606863989598,0.000868715233864152,0.000724555764300835,0.000575398026825554,0.000428892765703756,0.000291697950092435,0.000169153555903506,6.50425016420128e-05,-1.85234374016095e-05,-8.1062510327741e-05,-0.000123514459115628,-0.000147877139313092,-0.000156728085011584,-0.000152695292261241,-0.00013795804967952,-0.000113863069752506,-8.07311016065105e-05,-3.79046926646355e-05,1.59485069766728e-05,8.23054874627851e-05,0.000162102226256703,0.000254999779975862,0.000358730683760356,0.000468656501929132,0.000577648313604746,0.000676362664087937,0.000753930605996921,0.000799014313782005,0.000801123680418831,0.000752034111365119,0.000647115216621322,0.000486374574583438,0.000275043850791223,2.35846551473468e-05,-0.000252937283296738,-0.000536078144953859,-0.000805727697105372,-0.00104212075499802,-0.00122791356832273,-0.00135007118125491,-0.00140132610791291,-0.00138101521887205,-0.00129517494582053,-0.0011558654641411,-0.000979790646898602,-0.000786369698337525,-0.000595486748690707,-0.000425187071766563,-0.000289597422176121,-0.000197322135594918,-0.000150509439476463,-0.000144701202607295,-0.000169484381917711,-0.000209865562750849,-0.000248203154686815,-0.000266465493464747,-0.000248545116172165,-0.000182354052888256,-6.14523551684281e-05,0.000113981410260108,0.000336950391824526,0.000594231994872086,0.000867691616605338,0.0011361631516989,0.00137767775719352,0.0015717849503938,0.00170170356216631,0.00175606475692563,0.0017300617407767,0.00162589391415011,0.00145247750491424,0.00122447925393526,0.00096080381109566,0.000682720104063908,0.000411840971321016,0.000168171482567749,-3.15836861431464e-05,-0.0001753093140578,-0.000256279164223295,-0.000273441744161637,-0.000231223768017232,-0.000138925070961914,-9.80328498031421e-06,0.000140047130522439,0.0002929258056124,0.000430789843410304,0.000536492585317829,0.000594956579967958,0.00059424643754532,0.000526503746384431,0.000388694652221126,0.00018310645263271,-8.24801377861826e-05,-0.000395014312864434,-0.000736846207781068,-0.00108685986573383,-0.00142202857022198,-0.00171929058125856,-0.00195758296394199,-0.00211982487483947,-0.00219462023512474,-0.0021774605139699,-0.0020712534185638,-0.00188607861341935,-0.00163816747772926,-0.00134820649351195,-0.00103915741033918,-0.00073385692719499,-0.000452692696972996,-0.000211644778485528,-2.09324886338731e-05,0.000115577281701406,0.000200150550845124,0.000240218686230826,0.000246828469147548,0.000232752230939162,0.000210540248666932,0.000190794815808799,0.000180901305251981,0.000184373714400366,0.000200873325211211,0.000226854896143593,0.000256701283830888,0.00028413842238455,0.000303687683235486,0.000311915661399616,0.000308280293216932,0.000295439553654865,0.000278973677592439,0.000266560930474839,0.000266727647601014,0.000287354795792673,0.000334158237460241,0.000409364777325132,0.000510781632410091,0.000631407502164377,0.000759666005859803,0.000880265652402976,0.00097561399585878,0.00102764594324371,0.00101987460441786,0.000939442786663774,0.000778946944644182,0.000537823252589212,0.000223125246927017,-0.000150420022738885,-0.000561120889757834,-0.000981763628000644,-0.00138168380807347,-0.00172929627367022,-0.00199486245396718,-0.00215324183210143,-0.00218636527426636,-0.00208518337124421,-0.00185088265094907,-0.00149522393063226,-0.00103993541195018,-0.000515181642807963,4.27800277649939e-05,0.000594560369688652,0.00110095382837828,0.00152630214762394,0.00184158530551194,0.00202693746917677,0.00207333625984034,0.00198329207978781,0.00177046287882997,0.00145822815992144,0.00107736242336206,0.000663040799129036,0.000251477931543025,-0.000123462423274669,-0.000433349206796724,-0.000657654903428922,-0.000785380359334674,-0.00081568993239839,-0.000757518575142196,-0.000628219869702501,-0.000451421943279771,-0.000254336150547533,-6.48133064766461e-05,9.1540832719015e-05,0.000193896395316664,0.000228130781820508,0.000187988685309581,7.5388554100483e-05,-0.000100111924795088,-0.000322590142708361,-0.000571599138951026,-0.000824352394569267,-0.00105801056425524,-0.00125183639222139,-0.00138901825287514,-0.00145801637049396,-0.00145335042073785,-0.00137581363000971,-0.00123215785867215,-0.00103433940298284,-0.000798442028344111,-0.000543400995517831,-0.00028964181130274,-5.77251173610517e-05,0.000132938801295612,0.000265268957090676,0.000325568355889838,0.000304444950486963,0.00019758566762225,6.35691572520547e-06,-0.000261813435798565,-0.000593334686578598,-0.000968703600787194,-0.00136317251784047,-0.00174787909961472,-0.00209144146514361,-0.00236196801917932,-0.00252936933463891,-0.0025677995023447,-0.00245800707175845,-0.00218935104297035,-0.00176124272287106,-0.00118381285091175,-0.000477673326004665,0.000327263031041503,0.00119383457638358,0.00208037990430556,0.00294392110581607,0.00374346076831466,0.00444305394816518,0.00501434096959255,0.00543829166943012,0.00570600785417845,0.00581854488683633,0.00578582959477719,0.00562485417929885,0.00535740099639126,0.00500759179686433,0.00459955363560641,0.00415545439767367,0.00369409120641878,0.00323012625628688,0.00277397030784607,0.0023322276757991,0.00190854957820312,0.00150470323303695,0.00112165563864204,0.000760492370704775,0.00042303751263057,0.000112102361063916,-0.000168642527253228,-0.000415115435517377,-0.000623487116751469,-0.00079092719551613,-0.000916295072547568,-0.00100065324851514,-0.00104751474927567,-0.00106278125813605,-0.00105437705475443,-0.00103162839705852,-0.0010044721934012,-0.000982597330404848,-0.000974624978754023,-0.000987421340227759,-0.00102561073246677,-0.00109132353232584,-0.0011841781952983,-0.0013014652576396,-0.00143847891146325,-0.00158893167003503,-0.00174539073939684,-0.00189968941928659,-0.0020432894003704,-0.00216759494131168,-0.00226424184846174,-0.00232539781655086,-0.00234411250958109,-0.00231474456154775,-0.00223346982490629,-0.00209884444644497,-0.00191236326144242,-0.00167892505682035,-0.00140709788293312,-0.00110907514262229,-0.000800230045427827,-0.000498212921838741,-0.000221590523563412,1.19066361513555e-05,0.00018739176852635,0.000294881793558805,0.000331158899316793,0.000301160669884192,0.000218637754034773,0.000105867835153886,-7.69887633187517e-06,-8.78708229032314e-05,-9.90962019878101e-05,-8.52990343873819e-06,0.000209599130439318,0.000569792402203212,0.00107176709482735,0.00169810669599837,0.00241347335531349,0.00316563120013003,0.00388833772433067,0.00450594445375784,0.00493933462836663,0.0051126427019841,0.00496007422441426,0.00443209565589246,0.00350030345795072,0.00216041077821631,0.000432996463675318,-0.00163807807641434,-0.00398939542069673,-0.00654339456980373,-0.00921479419140918,-0.0119172168672843,-0.0145691741663396,-0.0170986544487752,-0.0194457427740247,-0.0215629733999434,-0.023413436263572,-0.0249669878532854,-0.0261952099926879,-0.0270659767278712,-0.0275385981384192,-0.0275604920816721,-0.0270661880106075,-0.0259792048031133,-0.024216995597054,-0.0216987570905793,-0.0183555055998734,-0.0141414755100714,-0.00904564109976626,-0.00310203358148679,0.00360245899549312,0.0109239576233869,0.0186619748467085,0.0265647617987532,0.0343396001183738,0.0416675346219802,0.048221590668919,0.0536871468985831,0.0577828775511805,0.0602805652813105,0.0610221273770541,0.0599323924924521,0.0570264935250394,0.0524111745041776,0.0462798051875707,0.0389014110462683,0.0306045122505884,0.0217569806569258,0.0127434337036936,0.00394186402712921,-0.00429875898184896,-0.0116782845871466,-0.0179611779412632,-0.0229872687815969,-0.0266768246103981,-0.02902978730346,-0.0301194813358459,-0.0300815349075825,-0.0290991155932373,-0.0273858391524019,-0.0251678422504698,-0.0226665068892823,-0.0200831890302934,-0.0175870518930989,-0.0153067630356356,-0.0133264196765545,-0.0116856597398285,-0.0103835379301406,-0.00938543350127516,-0.008632037518374,-0.00804935923433248,-0.00755869777533818,-0.007085638020563,-0.00656732859323569,-0.00595755714820194,-0.00522942084468675,-0.00437566456950336,-0.00340699594308673,-0.00234886089030783,-0.00123726220113484,-0.000114221988154812,0.000976566587002261,0.00199346758163813,0.00289973233516946,0.0036653192791702,0.00426774727009332,0.00469215133686051,0.00493078986771031,0.00498228078919992,0.00485082263109766,0.00454559317884348,0.00408042779230095,0.00347377851484094,0.00274886122158739,0.00193382648343249,0.00106175161247511,0.000170252149798932,-0.00069944935783466,-0.00150408683543774,-0.00220054068326649,-0.00274854416978045,-0.0031136974563163,-0.00327050208499582,-0.003205082636678,-0.00291725657666617,-0.00242165116818159,-0.00174764533767019,-0.000938026773854242,-4.63880881256598e-05,0.000866574790237188,0.00173757031035989,0.00250563168258297,0.00311699477050195,0.00352946521601779,0.00371584511047776,0.00366607660603589,0.00338788631456511,0.00290586617891373,0.00225908654716139,0.00149748715782712,0.000677414503805893,-0.000143244341728059,-0.000909849889237055,-0.00157526051873322,-0.00210315648788548,-0.00247016126623627,-0.00266662240189875,-0.00269606251483209,-0.00257345165869629,-0.00232256918302271,-0.00197280380960001,-0.00155577727608081,-0.00110216762708359,-0.00063905673321555,-0.000188041480872247,0.000235758557816796,0.000623778338566481,0.000973258604910555,0.00128584962725139,0.00156580755422907,0.00181805257512143,0.0020463537233666,0.00225187055183485,0.00243222353937326,0.00258119156663624,0.0026890556445637,0.00274353245888704,0.00273117698003073,0.00263908603689593,0.00245670758130952,0.00217755420061462,0.00180063303966449,0.00133143489281228,0.000782369026079307,0.000172582925621882,-0.000472836972363066,-0.00112423108825994,-0.00174919510072387,-0.0023147247321196,-0.00278950126413416,-0.00314612823136282,-0.0033631328344658,-0.00342656560879413,-0.00333106701460914,-0.00308031650225397,-0.00268683353233525,-0.0021711554354674,-0.00156046814951344,-0.000886807651638268,-0.000184978526429998,0.000509650320630643,0.0011633140962508,0.00174584008243291,0.00223233398650076,0.00260447244474103,0.00285134013119893,0.00296977965069545,0.00296424968901206,0.00284621149734088,0.0026330863160232,0.00234684772313914,0.00201233375551679,0.00165538379306196,0.00130092328123604,0.00097113290894505,0.000683844582805112,0.000451301029341388,0.000279396422724925,0.000167480996556032,0.000108764388359563,9.12943511159692e-05,9.9425735552794e-05,0.000115637246929649,0.000122508804716152,0.000104647783567612,5.03530090339891e-05,-4.71672954150516e-05,-0.000189155724877746,-0.000371306295004713,-0.000584388717059876,-0.000815402492357422,-0.00104910248052786,-0.00126969493605744,-0.00146248823541247,-0.00161529759312418,-0.00171944551667954,-0.00177026301303544,-0.00176707095592557,-0.00171269524204974,-0.00161263223356551,-0.00147402324884562,-0.00130461266579854,-0.00111185200351568,-0.000902275125439824,-0.000681214390443811,-0.000452863827514159,-0.00022063394960284,1.23063734132879e-05,0.000242434908253511,0.000465367311813166,0.000675555668153453,0.000866277025588486,0.00102994334287232,0.00115870864572578,0.0012452982736599,0.00128394667659545,0.00127130973285996,0.00120721729105877,0.00109515055255151,0.000942363091325468,0.000759607902195767,0.000560479313773989,0.00036042182894129,0.000175493295016047,2.09944449512643e-05,-8.99102003011641e-05,-0.000147453389820216,-0.000146289795578703,-8.61826983285581e-05,2.77249171923099e-05,0.000185102475382912,0.000371099595984789,0.000567462849177287,0.000754033360172467,0.000910516230398956,0.00101837615757699,0.00106268605703333,0.00103374186119581,0.000928261376352784,0.000750010921685559,0.000509750811885735,0.000224456818116417,-8.41464583276457e-05,-0.000391621678796494,-0.000673229780952926,-0.000906463178984672,-0.00107341754274829,-0.00116272151432945,-0.0011707826948111,-0.00110218035172983,-0.000969132762733419,-0.000790078106046838,-0.00058751809166871,-0.000385368464277271,-0.000206127202408036,-6.82004001371554e-05,1.62869222266449e-05,4.29213662440356e-05,1.5487340293228e-05,-5.4565012656632e-05,-0.00014962181811,-0.000248211042767588,-0.000327845438751897,-0.000368066934867242,-0.000353325478235605,-0.000275337147088676,-0.000134620450170849,5.89994273372158e-05,0.000287011054074009,0.000523923505465812,0.000739892105742128,0.00090398430508118,0.000987726412416346,0.000968532603662979,0.000832624527443033,0.000577102356029652,0.000210920094896884,-0.000245361600767048,-0.000761037254903025,-0.00129779221068154,-0.00181305513709352,-0.00226382414152437,-0.00261057584124886,-0.00282086273366599,-0.00287224300630611,-0.00275426323301644,-0.0024693188886024,-0.00203233806194215,-0.00146935643077798,-0.000815162778998031,-0.000110281952053717,0.000602383028822366,0.00128091110085193,0.00188740855259662,0.00239047858807463,0.00276693584630928,0.00300268311694622,0.00309276562879321,0.0030407054527873,0.00285728413029088,0.00255897852499228,0.00216626054488936,0.0017019480464164,0.0011897484778851,0.00065307827223209,0.000114180595892457,-0.000406487897117608,-0.000890666251439015,-0.00132257420524913,-0.00168914691322617,-0.00198027013852711,-0.00218903280258724,-0.00231197735194264,-0.00234929748527453,-0.00230491403259311,-0.00218635731364741,-0.00200439912293365,-0.00177240742235411,-0.00150543698832992,-0.00121911293287036,-0.00092840375394966,-0.000646409418652897,-0.00038330259794251,-0.000145554657060947,6.44476473233836e-05,0.000248330734704914,0.000411196898758526,0.000560666931072291,0.000705601860137389,0.000854645710519673,0.00101475747309667,0.00118990671631671,0.00138009240492211,0.00158081011963837,0.00178304299836371,0.0019737922747309,0.00213710142349906,0.00225547116952838,0.00231151798753436,0.00228970179139962,0.00217794264113392,0.00196896207002414,0.00166121968309531,0.00125936491651335,0.000774180170984921,0.000222046887184959,-0.000375987186425397,-0.0009954293348174,-0.00160972779998458,-0.00219170271020811,-0.00271492215018001,-0.00315495295482976,-0.00349044810783639,-0.00370406093622349,-0.00378319519513705,-0.00372060668430396,-0.00351486628248866,-0.00317067918219988,-0.00269903580201356,-0.00211715251899452,-0.00144815080529383,-0.000720425720092588,3.33294150313672e-05,0.000777447249219332,0.00147492824489159,0.00208932976685329,0.00258679654149942,0.00293810024423859,0.00312054272844656,0.00311957903471006,0.00293003223303269,0.00255679979459179,0.0020149867239883,0.0013294398373094,0.000533696446223457,-0.000331603641958465,-0.0012207632010061,-0.00208542496430059,-0.0028771966619328,-0.00355036397329673,-0.00406454102095371,-0.00438710221953534,-0.00449523949391631,-0.00437749703242788,-0.00403465413540639,-0.00347985737011004,-0.00273794712005833,-0.00184397990421193,-0.00084101340178406,0.000222709651214678,0.00129697731924646,0.0023329703754769,0.0032864857762428,0.00412073490036331,0.00480845962189894,0.0053331708246396,0.00568940201460541,0.00588197578036168,0.00592439030411212,0.0058365327106953,0.00564200203369915,0.00536536587291858,0.00502967476950938,0.0046545159972901,0.0042548090393336,0.00384043922138391,0.00341670860460667,0.00298547095468989,0.00254672635686459,0.00210039362320292,0.00164796271311958,0.00119375642911092,0.000745595840269222,0.000314757022321392,-8.47861205065408e-05,-0.00043773241407054,-0.000729247149857677,-0.000946927146989615,-0.00108265925562717,-0.00113410644918511,-0.00110560301663776,-0.00100831579915058,-0.000859621350915088,-0.00068174703327494,-0.000499814977426571,-0.00033950061400625,-0.000224563765256769,-0.000174525299142523,-0.000202745075508346,-0.000315110181964247,-0.000509472402871128,-0.000775889162645912,-0.0010976329831653,-0.00145285121138345,-0.0018166898758103,-0.00216365045152161,-0.0024699306123045,-0.00271551091515783,-0.00288578651800144,-0.00297260105514927,-0.00297461086087694,-0.00289698268488106,-0.0027504976773634,-0.0025501907505334,-0.00231369173676374,-0.00205945027237087,-0.00180502032242944,-0.0015655557543246,-0.00135263045076708,-0.00117345137068615,-0.00103048716840615,-0.000921494241802687,-0.000839890785801373,-0.000775410107349735,-0.000714957591443468,-0.000643599821925375,-0.000545626384812776,-0.000405640704265254,-0.000209651422171362,5.38537185725268e-05,0.000392866692198335,0.000810871841714636,0.00130594723047572,0.00187000806947432,0.00248826421712462,0.00313897701560167,0.00379360345049566,0.00441740399024516,0.00497056295162514,0.00540982809126661,0.00569062333428746,0.00576953135184339,0.00560698867845357,0.0051699930808227,0.00443459798855809,0.00338796720970024,0.00202978757604762,0.000372887293337975,-0.00155701984738566,-0.00372245608056089,-0.00607606389624794,-0.00856305898643685,-0.0111239832573732,-0.0136974418284957,-0.0162224973244175,-0.0186404270485503,-0.0208956250414515,-0.0229355469364467,-0.0247097400839311,-0.0261681581418692,-0.0272591076455007,-0.0279272916938792,-0.0281124818140255,-0.0277493467088645,-0.02676888673413,-0.0251017659150605,-0.0226836101185684,-0.0194620720692741,-0.0154051813192405,-0.0105102356092181,-0.00481228605070831,0.0016088446993551,0.00862406999005249,0.0160540015775406,0.0236720419063499,0.0312119215471359,0.0383795650146442,0.044868708438869,0.0503792560427329,0.0546370004010667,0.0574130894385703,0.0585415347937497,0.0579331389755284,0.0555844710997267,0.0515809218759253,0.0460933793856901,0.0393686362412149,0.0317142068382256,0.0234787411980804,0.0150296166155113,0.00672953009890833,-0.00108601925347313,-0.00812858153576321,-0.0141724403771099,-0.019065036234309,-0.022731527075925,-0.0251734121574649,-0.0264616543429544,-0.0267251811966753,-0.0261359867153282,-0.0248922685311803,-0.0232011082713695,-0.0212621381690462,-0.0192534502474719,-0.0173207207468387,-0.0155701740838996,-0.0140656330306889,-0.0128295304041959,-0.011847424640876,-0.0110752937345499,-0.0104486981023061,-0.00989281328342229,-0.00933233924865237,-0.00870038723839038,-0.00794561281022761,-0.00703708487554938,-0.00596663119787445,-0.00474865628820132,-0.00341766428371392,-0.00202391693208883,-0.000627799769251793,0.000706451609069746,0.0019170018670975,0.00295003247220045,0.00376422261335674,0.0043337431491772,0.00464958766147251,0.00471924613069156,0.00456489531392234,0.00422041860565397,0.00372766368617747,0.0031323904274423,0.00248035219516835,0.00181389501066089,0.0011693609196738,0.000575458718505397,5.26338049096686e-05,-0.000386653511936956,-0.000736930360860523,-0.000998247001527063,-0.00117452180893167,-0.00127195502535836,-0.00129772063319149,-0.0012590722515308,-0.00116291488514207,-0.00101581267046946,-0.000824334865065778,-0.000595596495969342,-0.000337830619153347,-6.08361792216782e-05,0.000223824588988298,0.000502958770242996,0.000762229800617998,0.000986967734700274,0.00116322283614399,0.0012789463639731,0.00132516221771765,0.00129699015143395,0.00119439475644156,0.00102256183935654,0.00079184145919315,0.000517240295031739,0.000217490539286973,-8.62362625668189e-05,-0.000371867866134531,-0.000618095746402285,-0.000806026158871771,-0.000920678802603043,-0.000952206230878729,-0.000896730141019088,-0.0007567223556055,-0.000540895938643491,-0.000263612270394132,5.61503964100617e-05,0.000396185737522706,0.000732695794568735,0.00104204621217563,0.00130250323993123,0.00149581863163084,0.00160854250887923,0.00163296741325584,0.00156763686852504,0.00141738607987846,0.00119291804905037,0.000909952681983879,0.000588017084459856,0.000248970345211851,-8.46256269472155e-05,-0.000391167066180186,-0.000651576530498566,-0.000850659566262913,-0.000978145141737475,-0.0010293269572512,-0.00100525165768518,-0.000912434783971176,-0.000762124112992239,-0.000569170133107307,-0.000350601259078386,-0.000124032913581561,9.39393793833836e-05,0.000289205821744788,0.000451319496200209,0.000574263542192838,0.000656728347994032,0.000701871093771515,0.000716587612752866,0.000710382658491041,0.000693972307135855,0.000677785186946202,0.000670542939775844,0.000678092491892318,0.000702633714725553,0.000742438948874078,0.000792101061616261,0.000843281329508071,0.000885865438792351,0.000909383103977428,0.000904510981494828,0.000864464585138332,0.000786095171018831,0.000670541533783603,0.000523340833842442,0.000353970713478341,0.000174868709445943,4.48454137308169e-08,-0.000156540133162764,-0.000282623221025759,-0.000369098410395776,-0.000411091729611732,-0.000408505342419739,-0.0003659540710854,-0.00029210060011009,-0.000198480007241739,-9.79779742920005e-05,-3.17874972531243e-06,7.51799665278208e-05,0.000129421994100961,0.000155642495557664,0.00015381394436891,0.000127282978151057,8.17493504656033e-05,2.39025150189139e-05,-4.00502486258279e-05,-0.000105707945798435,-0.000171414425451481,-0.000238631116251701,-0.000311652359726849,-0.000396678564168752,-0.000500371051912527,-0.000628105949148002,-0.000782207605342235,-0.00096046385845995,-0.00115520096074923,-0.0013531269895186,-0.00153604773490026,-0.00168243278418976,-0.00176968002801367,-0.00177681353019364,-0.00168727036128897,-0.00149139982071324,-0.00118831994924473,-0.000786849840383367,-0.000305352435306984,0.00022953508037873,0.000785158085583305,0.0013258313199531,0.00181620177497414,0.00222458631183216,0.00252589060985377,0.00270377727266963,0.00275185530415016,0.00267379453638549,0.00248240738810876,0.00219786672340219,0.00184532546703854,0.00145225907400325,0.00104586068207048,0.000650782627785396,0.00028744521560318,-2.89627844792974e-05,-0.000288771932894364,-0.000487485240516278,-0.000624949874084742,-0.000704246950543976,-0.000730511086133467,-0.000709870684313024,-0.000648652399711029,-0.000552928308179229,-0.000428413452050011,-0.000280656142706089,-0.000115413644288951,6.09213855566122e-05,0.000240979981845816,0.000416274999726496,0.000577329667809255,0.000714094495037336,0.00081661525623927,0.000875867318969799,0.000884639657104302,0.000838340394812721,0.000735605849581301,0.000578624264594127,0.000373128025209725,0.000128056344550746,-0.000145064251330243,-0.000432939337046221,-0.000721424296076249,-0.000996437263782055,-0.00124477942915505,-0.00145480242737757,-0.00161689629937893,-0.00172380430413858,-0.00177079628387355,-0.00175574567705103,-0.00167915470103326,-0.00154415872539257,-0.00135651820207372,-0.00112458045065632,-0.000859170688241953,-0.000573358039006939,-0.000282042227145921,-1.32193937308264e-06,0.000252365001015358,0.000463300884794703,0.000617676549516787,0.000704802011588548,0.000718207492313154,0.000656495576277257,0.000523817895785267,0.000329882055152317,8.94429047663376e-05,-0.000178709434819005,-0.000453192042658565,-0.000711775268874725,-0.000933265094165231,-0.00109933335951938,-0.00119610859184758,-0.00121536345644854,-0.00115517734964976,-0.00102000894613691,-0.00082017671666235,-0.000570808010475557,-0.000290372082479358,1.0465447622385e-06,0.000283554923833426,0.000539156114167982,0.000753185038842605,0.000915343247120374,0.00102024676471144,0.00106745564588932,0.00106101007874076,0.00100854999526878,0.000920137680333463,0.000806931429637784,0.00067986985254902,0.000548519663267033,0.000420215424245134,0.00029958037592221,0.000188467714592904,8.63073810551226e-05,-9.20873102877431e-06,-0.0001012136303588,-0.000192663574098769,-0.000285397872985817,-0.000379400640840582,-0.000472376482257642,-0.000559708207829275,-0.000634811117694264,-0.000689842423079,-0.000716673704909703,-0.000707996091628512,-0.000658407607959683,-0.000565332946828388,-0.000429647770262247,-0.000255919465540807,-5.22282751438061e-05,0.000170410776815931,0.000398952082219427,0.000619435632036982,0.000818177487569897,0.000982893881693423,0.00110363571691184,0.00117344456223701,0.00118868635266367,0.00114906709645942,0.00105737792767023,0.000919047815900922,0.000741596474117703,0.000534075944035501,0.000306568888541134,6.97797879901082e-05,-0.00016528082599604,-0.000387551381964234,-0.000586167563784781,-0.000750764277777637,-0.000871881053989041,-0.00094149488066584,-0.000953668378575577,-0.000905261619822709,-0.000796620379905159,-0.000632129282460757,-0.000420510643828076,-0.000174761891803969,8.83436811149446e-05,0.000349219331504025,0.00058685712107752,0.000780553685124141,0.000911816051160473,0.000966251721992651,0.000935227180218436,0.000817085908440755,0.000617752033419747,0.000350605841894041,3.55959407002024e-05,-0.000302359916310837,-0.00063554854982012,-0.000936001687213574,-0.00117814681903086,-0.00134129367359998,-0.00141169432588699,-0.00138395789586976,-0.00126166826600029,-0.00105713690259905,-0.000790312699834348,-0.000486956485927801,-0.000176260156606163,0.000111857876354977,0.000349522529884673,0.000513478445997004,0.000587238595187891,0.000562615849986586,0.000440508402804984,0.000230878489178209,-4.80656110023415e-05,-0.000371407829556114,-0.000709648810093392,-0.00103123774317711,-0.0013053028533294,-0.00150435849649142,-0.00160677009733056,-0.00159877726631324,-0.00147590867173737,-0.00124366706900123,-0.000917416129894286,-0.000521458786642439,-8.73560012254383e-05,0.000348408388461073,0.000747260086095584,0.00107166500643997,0.00128832810087526,0.00137121280924832,0.00130413200343904,0.00108267736632264,0.000715289139847561,0.000223322227950338,-0.000359963684454692,-0.00099147650235616,-0.00162131882497961,-0.00219656723382252,-0.00266551546248762,-0.00298202675824727,-0.00310960351081984,-0.00302478190988243,-0.00271950027770923,-0.00220217142793585,-0.00149730627815799,-0.000643677213345265,0.000308839595558046,0.00130346098654598,0.00228133365963823,0.00318653585171725,0.00397074410547324,0.00459709702961767,0.00504287297349601,0.00530072735800989,0.00537839278741516,0.00529691223447676,0.00508763273585764,0.00478831589477637,0.00443880762767619,0.00407674408855446,0.00373375106456652,0.00343252435200094,0.00318506840373323,0.00299223386144112,0.0028445477741646,0.00272418996687927,0.00260785011747722,0.00247011439400487,0.00228698556000229,0.00203913919830493,0.00171455949918126,0.0013102752140923,0.000833020930035093,0.000298769507134914,-0.000268794179577935,-0.000840672869278844,-0.00138555039895784,-0.00187303632180846,-0.0022767938311724,-0.00257719945365385,-0.00276323951490209,-0.00283343930584322,-0.00279573595617661,-0.00266633165239025,-0.00246768462444783,-0.00222589605944692,-0.00196781884720794,-0.00171824004031742,-0.00149746985099672,-0.00131960874740853,-0.00119166938781251,-0.00111361497353562,-0.00107925601809447,-0.00107783976811619,-0.00109608479021526,-0.0011203677190715,-0.00113876458592855,-0.0011426843228417,-0.00112790024661714,-0.00109487554240931,-0.00104837748726414,-0.000996468515239371,-0.000949038053654184,-0.000916088514447063,-0.000906007403406558,-0.00092404531085261,-0.000971180827527228,-0.00104349561129693,-0.00113211516306043,-0.00122370297972984,-0.00130143629003917,-0.00134634714338546,-0.00133888706647151,-0.00126056769035405,-0.0010955417430594,-0.00083201440832338,-0.000463408614013208,1.07568831669246e-05,0.000584286590593638,0.00124401225219021,0.00196975896413642,0.00273455277618861,0.00350506192005934,0.00424228315788695,0.00490250461436664,0.00543858987220804,0.00580162843172758,0.00594297999016679,0.0058167026101787,0.00538229995551077,0.00460765685464236,0.00347196563785264,0.00196839035137287,0.000106184677638237,-0.00208801731120662,-0.00456997435045391,-0.00727882678745856,-0.0101393330312783,-0.013065244654849,-0.0159635669477637,-0.0187393253363667,-0.0213003702689625,-0.0235617210831433,-0.025448983629149,-0.0269004787817642,-0.02786788125738,-0.02831537253905,-0.0282175324705518,-0.0275564006070537,-0.0263182992042774,-0.0244910968117206,-0.0220625846342579,-0.019020528330102,-0.015354750592529,-0.0110613139345997,-0.00614854088516857,-0.000644272562909998,0.00539652640843967,0.0118849123138317,0.0186930276841919,0.0256521830632113,0.0325548171872361,0.0391608226315839,0.0452082447529652,0.0504278329211767,0.0545604103907716,0.0573756010483332,0.0586901689720899,0.0583841354056793,0.0564129592125546,0.0528143956108346,0.0477091508721479,0.0412950707364396,0.0338352639599643,0.0256411891837731,0.0170522466344528,0.00841375386365492,5.53074644741875e-05,-0.00772857073937098,-0.014693915990514,-0.0206578192542637,-0.025503404269526,-0.0291793439815575,-0.0316945269706693,-0.0331089211417523,-0.0335219605776598,-0.0330598807224273,-0.0318633506380967,-0.0300765254155338,-0.0278383107066301,-0.0252762484333166,-0.0225030532436601,-0.0196155022544291,-0.0166951427093103,-0.0138101538842305,-0.0110176840474556,-0.00836606775231987,-0.00589648794951081,-0.00364384845941161,-0.0016368300995371,0.00010271402416113,0.00156073697948478,0.00273199731267182,0.00362073010546924,0.0042407073173913,0.00461451868091356,0.00477204371783903,0.00474822647475436,0.00458038481811739,0.00430536754397789,0.00395690388605251,0.00356346799134547,0.0031469103569422,0.00272200083726504,0.00229690038102601,0.00187445028914304,0.00145405722774182,0.00103387512333177,0.000612951806785205,0.00019302266355953,-0.000220307569027231,-0.000617159820416093,-0.000983802824976815,-0.00130383406234186,-0.00155994541489896,-0.00173602091812528,-0.00181927261239495,-0.00180212058109873,-0.00168356303155742,-0.00146985452779601,-0.00117440385705869,-0.000816903850371589,-0.000421799909951492,-1.62799068260478e-05,0.000371983285483313,0.000717088546635316,0.000996929367256433,0.00119479189265524,0.00130039926153074,0.00131034544361041,0.00122793365605851,0.00106249666213202,0.000828321530026171,0.000543325518552917,0.000227631908848278,-9.78225842671784e-05,-0.000412548430972856,-0.000697569941316198,-0.000936274228009628,-0.0011150504312525,-0.00122374762716776,-0.00125598692201479,-0.00120935743517165,-0.00108551017040231,-0.000890143013537486,-0.000632850106102235,-0.000326795402532004,1.18320032510321e-05,0.000364611521490211,0.00071193878107161,0.00103429566864576,0.00131366822417151,0.00153499652041259,0.00168750851730663,0.00176577438653059,0.00177032439847795,0.00170770456186415,0.0015898984831564,0.00143311619864432,0.00125603250132431,0.00107763770446457,0.000914931166905123,0.000780731371963599,0.000681887463725597,0.000618151288409277,0.000581906320515222,0.00055885565733936,0.000529655632388333,0.000472358403327874,0.000365412114042867,0.000190876928711627,-6.25368596405578e-05,-0.000397006943235573,-0.000804065085085886,-0.00126424859708,-0.00174806236255964,-0.00221822167101173,-0.00263298757588621,-0.0029502644004116,-0.00313202209827146,-0.00314854915700687,-0.00298204332163702,-0.00262910900565347,-0.00210184557364564,-0.00142736645852419,-0.000645766670328601,0.000193266012362276,0.00103484491949209,0.00182381729835842,0.0025097102151017,0.00305116623720293,0.00341940937735677,0.0036003980407252,0.0035954751209801,0.0034204962931568,0.00310358477255256,0.00268180450910547,0.00219714800206079,0.00169228940369046,0.0012065547474694,0.00077251205201068,0.000413493559542328,0.000142243536243244,-3.92467570447766e-05,-0.000138784525453181,-0.000172081549266114,-0.000160186262948731,-0.000126557809857508,-9.41118168732963e-05,-8.25461185490935e-05,-0.000106203195093411,-0.000172652646918791,-0.000282091126275273,-0.000427568655823163,-0.00059596831215198,-0.000769598328897822,-0.000928207037109177,-0.00105120447545297,-0.00111987029307132,-0.00111934390628971,-0.00104022622380249,-0.00087966790014402,-0.000641871636324824,-0.000337990020935894,1.45493014124178e-05,0.000393216937196429,0.000771947695634412,0.00112297380641338,0.00141879223207889,0.00163413509990061,0.00174782173771633,0.00174438449649262,0.00161537586151219,0.00136027966855417,0.000986964237809784,0.000511630892240268,-4.1770464339319e-05,-0.000642664093116228,-0.00125548552926071,-0.00184177295821703,-0.00236261133170525,-0.00278128460141518,-0.00306595227167338,-0.00319213804855803,-0.00314480764915343,-0.00291982549874605,-0.00252461903211643,-0.00197794371348443,-0.00130872638606116,-0.000554059731629595,0.000243485909332214,0.00103898875020627,0.00178844408715509,0.00245186412246877,0.00299592176199695,0.00339591078016592,0.00363688160591515,0.00371391273258518,0.00363157710589141,0.00340274623362143,0.00304693094459583,0.0025883806782671,0.00205415293417367,0.00147232673758559,0.000870478549331767,0.000274477796025845,-0.000292396511834033,-0.000810057988920517,-0.00126199606608177,-0.00163550500500303,-0.00192181022856628,-0.0021161203271889,-0.00221760760083057,-0.0022292990718421,-0.00215784866804461,-0.00201316214207882,-0.0018078587301486,-0.00155657445115763,-0.00127513647773341,-0.00097966076705653,-0.000685641305972385,-0.000407105632959662,-0.000155906587812407,5.87944664970733e-05,0.00023081956925924,0.000357032935068663,0.000437182395854032,0.000473558920836056,0.000470522347541466,0.000433946555840393,0.000370635553436548,0.000287755226611875,0.000192316302624526,9.07347083864104e-05,-1.15123535316335e-05,-0.000110122023722111,-0.000202084540619741,-0.000285680128979817,-0.000360353673730208,-0.00042647391869221,-0.000484994037930552,-0.00053704304986015,-0.000583491008375316,-0.000624542591714662,-0.000659420529822739,-0.000686199359207515,-0.000701839252693135,-0.000702448622594401,-0.00068377421159336,-0.000641881792431562,-0.000573954369500468,-0.000479103867501663,-0.00035907269627858,-0.000218698252550973,-6.60292689014262e-05,8.79819408512694e-05,0.0002302358910928,0.000346653880276753,0.000423656751610396,0.000449797550410262,0.00041735164901235,0.000323652472617882,0.000171974000032321,-2.81968172055112e-05,-0.000261587499189071,-0.000508272728374836,-0.000745426741710144,-0.000949524790396081,-0.00109875597718317,-0.00117537096629233,-0.0011676841027296,-0.0010714822483234,-0.000890658802795068,-0.000636982713446345,-0.000329016808858878,9.69648585445832e-06,0.000352975048570804,0.000674593266394221,0.000950837627984243,0.00116273499555341,0.00129771278111352,0.00135052500027724,0.00132337118350447,0.0012252337610829,0.00107055090835507,0.000877414524535926,0.000665528544737583,0.000454176609908166,0.000260430061910584,9.77812890809659e-05,-2.46789317617398e-05,-0.000102498532546495,-0.000135551299606955,-0.000127276910233804,-8.36258246110242e-05,-1.18866409855324e-05,8.04263679039211e-05,0.000186471922552874,0.000300656959836143,0.000418835876161564,0.00053814333480194,0.000656528603122026,0.000772106128167308,0.000882465680086997,0.000984091837996562,0.00107202575434991,0.00113986407143668,0.00118013563420982,0.00118503373485904,0.00114741904667801,0.00106195554426878,0.000926207067266321,0.000741512146862372,0.000513472463071657,0.000251935077077176,-2.95845611798758e-05,-0.000315011643024767,-0.000587243853262708,-0.000829925569958328,-0.00102923523070124,-0.00117543953074714,-0.00126398710511002,-0.00129596864419428,-0.00127785358277578,-0.00122051430909788,-0.0011376526842671,-0.00104383481641304,-0.000952404072822197,-0.000873568459452112,-0.000812941489322357,-0.000770756796110081,-0.000741883879172685,-0.000716658799861027,-0.000682426107261687,-0.000625584237350065,-0.000533851558085826,-0.000398435120609839,-0.000215793915071876,1.12587895870324e-05,0.000273281617955673,0.000554817231930976,0.000835830836278897,0.00109380714732579,0.00130625230234533,0.00145329458549153,0.0015200640332988,0.00149855676067619,0.00138875129887123,0.00119883344948153,0.000944492286429888,0.000647360450946902,0.000332773914569218,2.71080667692759e-05,-0.000245001301933879,-0.000463228129776191,-0.000613616483032071,-0.000689889939392202,-0.000693858107313,-0.000634877406265217,-0.000528438644098592,-0.000394061421231422,-0.000252761142330256,-0.000124406996490804,-2.530131668976e-05,3.37198426944198e-05,4.84345888957641e-05,2.15005715062386e-05,-3.81772548653465e-05,-0.000116874997912639,-0.000198071309214063,-0.000264786129809897,-0.000301926124728117,-0.00029833350449801,-0.000248282100164542,-0.00015224400023382,-1.68499372629916e-05,0.000145927233267519,0.000320238551602938,0.000488269640790751,0.000632343627734836,0.000736950828372853,0.000790461243886892,0.000786327452772093,0.00072365881072575,0.000607132299111617,0.000446289267315694,0.000254339721519874,4.66478535212595e-05,-0.000160901467660448,-0.000353457283995547,-0.0005185076561355,-0.000646812134239095,-0.000732897731256756,-0.000775116423192396,-0.000775317616273269,-0.000738230491733826,-0.000670673838200447,-0.000580713364771178,-0.000476870397905632,-0.000367456084476819,-0.000260068536538689,-0.000161254275782922,-7.63067211873548e-05,-9.1582387449998e-06,3.76794622048841e-05,6.31601180019524e-05,6.77452742061933e-05,5.34319892812738e-05,2.37322643112724e-05,-1.64415115044243e-05,-6.10295716519895e-05,-0.000103244988810189,-0.000136161715624434,-0.000153435502058752,-0.000150086692826746,-0.000123244991834748,-7.27413058298011e-05,-1.43540517582659e-06,8.48081060145174e-05,0.000177541171442609,0.00026654214327154,0.000340946010816936,0.000390572249878731,0.000407286646895928,0.000386213764429966,0.000326622790367727,0.000232342147862808,0.000111614178960766,-2.36265522091506e-05,-0.000158989121453575,-0.000279240290995861,-0.000370103032171428,-0.000420013298906315,-0.000421607179814733,-0.000372740865177823,-0.000276904296126569,-0.000142967668357133,1.5713225105538e-05,0.00018272412217721,0.000340376379750223,0.000471630625621978,0.000561930622023841,0.00060073632087251,0.000582589677985589,0.000507610126629964,0.000381389084352922,0.000214324345363512,2.04965249965629e-05,-0.000183766115796574,-0.000381465160220481,-0.000556481545737796,-0.00069494561970692,-0.000786310370561356,-0.000824053896543805,-0.000805983514768089,-0.000734157181107258,-0.000614473257038769,-0.000456003930924038,-0.000270159453982899,-6.97703054108453e-05,0.000131835437702838,0.000321698640426139,0.000487997818312333,0.000620696445144964,0.000712059446241142,0.000757037716831658,0.000753521431206624,0.000702459587973005,0.00060783703461958,0.000476494304387244,0.000317773302280776,0.000142975932164563,-3.53653496032849e-05,-0.000204386558511956,-0.000351917237374544,-0.000467561107736736,-0.000543737917206425,-0.000576576034976234,-0.000566541526851829,-0.000518700638288097,-0.000442539504260829,-0.000351305788806161,-0.000260887882870044,-0.000188302527196746,-0.00014991451184634,-0.000159555521452609,-0.000226737087569727,-0.000355160381689643,-0.000541710818877528,-0.000776088261868343,-0.00104116673601057,-0.0013141060737845,-0.00156815878118545,-0.00177503685145043,-0.0019076338537073,-0.00194284555167615,-0.0018642043922932,-0.00166404413952118,-0.00134494258597986,-0.000920251232714741,-0.00041360620490603,0.000142583645453385,0.000709568183940691,0.0012454028861292,0.00170852480321551,0.00206141790020494,0.00227401086112858,0.00232647217644056,0.00221112589429768,0.00193330008640852,0.00151102837352452,0.000973640045754796,0.000359383193594087,-0.000287684071183572,-0.000921235911422914,-0.00149632560622757,-0.00197281141870184,-0.00231827089467471,-0.00251017370596761,-0.00253716182018455,-0.00239937353241671,-0.00210783582263459,-0.00168302950431861,-0.00115279704052729,-0.000549808910110406,9.11717268444999e-05,0.000735985185330819,0.00135351150487997,0.00191766421957887,0.00240881052086304,0.00281454576057739,0.00312981094094964,0.00335639843972789,0.00350193888722945,0.00357849737543151,0.00360092819889314,0.00358514391170175,0.00354644785857654,0.00349806174099908,0.00344995400367348,0.003408043809811,0.00337382190656021,0.00334439624487451,0.00331293890538685,0.00326948336627632,0.00320199866200989,0.00309765031100821,0.00294414741548066,0.00273107111508421,0.00245108146355744,0.00210090756493782,0.0016820392033419,0.00120105694031223,0.000669561316745578,0.000103689679530558,-0.000476759901022254,-0.00104954590316712,-0.00159145893962541,-0.00207994567947512,-0.00249475129558065,-0.00281944109027076,-0.00304266501108963,-0.00315904549777204,-0.00316959899740195,-0.00308164234165973,-0.00290818322500344,-0.00266684428917026,-0.00237841721511576,-0.00206518122149615,-0.00174914473771327,-0.00145037649348716,-0.0011855815547305,-0.000967049885785255,-0.000802062986332478,-0.000692793051487638,-0.000636675168183047,-0.000627182882692258,-0.000654897057382037,-0.000708731823521459,-0.000777172093420371,-0.000849384660094579,-0.000916087394137184,-0.000970094874211298,-0.00100649956400417,-0.0010224908995617,-0.00101685636895674,-0.000989245561349124,-0.00093930763395393,-0.000865832586297744,-0.000766035321927468,-0.000635117110310453,-0.000466220475131806,-0.000250860166148263,2.01346533857017e-05,0.00035519122874007,0.000760168068713355,0.00123629256860367,0.00177808044432634,0.00237149965056637,0.00299265943196849,0.00360729033229986,0.00417122958888329,0.00463203923189377,0.00493176758871816,0.00501073021033667,0.0048120492156089,0.00428656888605409,0.00339767826724087,0.00212553408564488,0.000470199741765041,-0.00154669854432091,-0.00388205465345473,-0.00647317459167012,-0.00924133915118257,-0.0120966939686643,-0.0149439504353139,-0.0176882647355844,-0.0202406230498759,-0.0225221093402148,-0.0244665675042535,-0.0260213793084343,-0.0271463395176141,-0.0278108875560339,-0.0279902137208678,-0.0276609603969969,-0.0267973530043588,-0.025368599389089,-0.0233382811285434,-0.020666232029278,-0.0173130795135299,-0.0132472486331085,-0.00845384100511176,-0.00294445176427445,0.00323327466845249,0.00998768318836438,0.0171780514355595,0.0246135582142073,0.0320570487098543,0.0392338921207078,0.0458456720317867,0.0515878778642942,0.0561702459841991,0.0593379985614697,0.0608920031899973,0.0607058638473503,0.0587381662991595,0.0550385229499703,0.0497466506806122,0.043084405096486,0.035341405933239,0.0268555368980914,0.0179901116037662,0.00910980541399952,0.000557526318751083,-0.00736576826847006,-0.0144166820129707,-0.0204193327305611,-0.0252691966408507,-0.0289310378029608,-0.0314316972439732,-0.0328489674532567,-0.0332980555917183,-0.0329172237131293,-0.0318540929760129,-0.0302538405661467,-0.0282501492488987,-0.0259593459288894,-0.0234777442749459,-0.0208818379395211,-0.0182307134825455,-0.0155698883422204,-0.0129357348391505,-0.0103597165469269,-0.00787181636923342,-0.00550274623315034,-0.0032847629935481,-0.00125114162903267,0.000565452338727518,0.00213531391774305,0.00343432688237775,0.00444642158272274,0.0051654741810429,0.00559636539273608,0.00575505133965929,0.00566764161467679,0.00536861057011055,0.00489837085028593,0.00430050201485218,0.00361894661810721,0.00289546257489492,0.00216756106769951,0.00146707503417283,0.000819408319111013,0.000243424150960773,-0.000248143689268165,-0.000647923535327306,-0.00095296851410283,-0.00116382473029824,-0.00128374382148662,-0.00131812405862742,-0.00127420147527524,-0.00116095245362516,-0.000989121431879121,-0.000771259237888343,-0.00052165299147593,-0.000256047736848386,8.90060642293102e-06,0.000256448506984487,0.00047081441856551,0.000638352605199033,0.000748711096944305,0.00079581682491957,0.000778538884687188,0.000700913181062449,0.000571864079249985,0.000404423465789418,0.000214515065879085,1.94317503084052e-05,-0.000163823142288405,-0.000320139183239909,-0.000437661336339264,-0.000508756664368332,-0.000530481653245533,-0.000504511156908381,-0.000436559028087638,-0.000335384706448877,-0.000211530860548673,-7.59679416610484e-05,6.11718123713887e-05,0.000191606631801266,0.000309540134704444,0.000411852914194626,0.000497851298729218,0.000568639785485954,0.000626239585046527,0.000672613327844851,0.00070876956396571,0.000734108019515071,0.000746129300269977,0.000740576135294339,0.00071200546190109,0.0006547214726408,0.000563939256542842,0.000437005818350333,0.000274486611454216,8.09345033709946e-05,-0.000134806296627601,-0.000359850796430779,-0.000578094944405748,-0.000771547531813862,-0.000922039400160619,-0.00101312092402887,-0.00103192614949746,-0.000970777540568334,-0.000828329767281724,-0.000610101210241626,-0.000328311331276868,-1.02184385765124e-06,0.000349340344353717,0.000697929967232305,0.00101969896223308,0.00129165079531492,0.00149490108193693,0.00161633540738576,0.00164970098811848,0.0015960310786431,0.00146337247857941,0.00126585920920349,0.00102224174291323,0.000754034380178717,0.000483478280812903,0.000231530974062788,1.60837618427126e-05,-0.000149422541015839,-0.000256862155696275,-0.000303709425772584,-0.000292751692965543,-0.000231301554243544,-0.00013003383239255,-1.608994826461e-06,0.000140740709367374,0.000284495040457701,0.000418862818189296,0.000535443229484631,0.000628499791907778,0.000694873812986212,0.000733614815506715,0.000745440549312088,0.000732153629356966,0.000696133603641466,0.000639994188225356,0.000566450905956843,0.000478392599076598,0.000379100865209594,0.00027252379177787,0.000163491929812652,5.77694199852961e-05,-3.81384801096039e-05,-0.000117452918717548,-0.000173837340719108,-0.000202276625070746,-0.000199986710935329,-0.000167194823581195,-0.000107630281065418,-2.85947365372385e-05,5.94644271985344e-05,0.000143880680889353,0.000211117816381273,0.000248390875606505,0.000245351277170512,0.000195601655609229,9.78132641228086e-05,-4.3738659681432e-05,-0.000219333294428111,-0.000414674775050392,-0.00061239280105125,-0.000793998683998562,-0.000942051786026932,-0.00104225427880557,-0.00108519492351663,-0.00106750553722946,-0.000992271197897239,-0.000868635944960754,-0.000710655045818827,-0.00053554682462722,-0.000361576815157811,-0.000205853319784072,-8.2320198360649e-05,-1.9970126214821e-07,3.69289367921428e-05,3.13201120742013e-05,-9.47272245755823e-06,-7.37553181976197e-05,-0.000147295388306096,-0.00021514150648321,-0.000263414838129572,-0.000280850039840734,-0.000259911167479966,-0.000197378882850222,-9.43850956743719e-05,4.40519004901667e-05,0.000209875938433345,0.000393069001286793,0.00058278532449674,0.000768387753724139,0.000940266740319248,0.00109037345380271,0.00121245485089163,0.00130203029269829,0.00135618799788792,0.00137329957717047,0.00135275001145336,0.00129476037240443,0.00120034631268944,0.00107141417609977,0.000910956783781159,0.000723280334734231,0.00051417833708038,0.000290971068941665,6.23493271146184e-05,-0.000162004611512395,-0.000372004234175769,-0.000557898402432447,-0.000711074534426281,-0.000824818360467587,-0.000894923553463056,-0.000920063658592791,-0.000901873463686547,-0.000844731064093796,-0.000755277376847538,-0.000641748463903639,-0.000513220764133895,-0.000378875893294203,-0.000247379204591933,-0.000126437568492823,-2.2562628959035e-05,5.89761732513944e-05,0.000114061127168152,0.00013957487998693,0.000133271975537764,9.37460224590606e-05,2.05378792734016e-05,-8.56081666586889e-05,-0.000222375456942748,-0.000385466413240605,-0.000568253742895049,-0.000761599748704094,-0.000953941262853119,-0.00113170781282377,-0.00128009558448209,-0.00138416610103506,-0.00143018435155572,-0.00140706473883608,-0.00130776206921046,-0.00113043421410038,-0.000879215523502524,-0.000564474821459854,-0.000202484956424608,0.000185504133553584,0.000574728339374084,0.000938784553712181,0.00125174464337617,0.00149030489472976,0.00163576122507731,0.00167561804012538,0.0016046775336246,0.00142551122182199,0.00114827957618268,0.000789931021874932,0.000372870846703088,-7.67625933802031e-05,-0.000531047089194016,-0.000962273283839302,-0.00134481949016201,-0.00165676068212546,-0.00188110584506458,-0.00200660316610753,-0.00202809897407694,-0.00194647815809799,-0.00176824633744607,-0.00150483431676483,-0.00117171234013476,-0.000787396413178427,-0.000372414370477613,5.1720401946706e-05,0.000463499897191565,0.000842365622428779,0.00116960344923571,0.00142918679521835,0.0016085574744125,0.00169931932545713,0.00169780348305372,0.00160545057136757,0.0014289486409221,0.001180069690849,0.000875163610814026,0.000534295614560053,0.000180048837096904,-0.000163946841473456,-0.000474661018639728,-0.000731354982965425,-0.000917172739390371,-0.00102048118351829,-0.00103582440727715,-0.000964388170858325,-0.000813915114710237,-0.000598064498457117,-0.000335266018208396,-4.71689213192205e-05,0.000243171080386516,0.000513198764005585,0.000742684603791512,0.000915304581734686,0.00101984026068348,0.00105090727321954,0.00100917025272611,0.000901053011895365,0.000737998364117264,0.00053536760606191,0.000311092495845402,8.42018789716432e-05,-0.000126657811385995,-0.000304601441202132,-0.00043569535715814,-0.000509892189870417,-0.000521665074421143,-0.000470315956704154,-0.000359950467787929,-0.000199128096008303,-2.12036726269504e-07,0.000221540994498341,0.000449094335823979,0.000664875645685503,0.000852065225073158,0.000995832418145667,0.00108442204247832,0.00111000015252679,0.00106918619993954,0.00096322615476942,0.000797795894965857,0.000582462029914911,0.00032986311631554,5.47025849511768e-05,-0.000227338930916963,-0.000500662612998887,-0.000750686252528582,-0.000964585998059267,-0.00113181149522138,-0.00124437846563872,-0.00129697600461464,-0.00128694869181126,-0.00121422179739035,-0.00108122991002243,-0.000892886779110645,-0.00065660154299939,-0.00038231051974293,-8.24621509829246e-05,0.00022812704503728,0.000532629883749082,0.000812845736109534,0.00105014703822435,0.00122671347603777,0.00132697511905592,0.00133913257088931,0.00125658293278298,0.00107906333465469,0.000813333983327622,0.000473260833474768,7.92202807123087e-05,-0.000343173161727984,-0.000764931157756407,-0.00115598513255109,-0.00148768658805442,-0.00173525835394757,-0.00187993943102501,-0.00191059670588735,-0.001824635)
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
      	def __init__(self): # only default arguments here
      		gr.sync_block.__init__(
      			self,
      			name ="e_Acum", # will show up in GRC
      			in_sig =[ np.float32 ],
      			out_sig =[ np.float32 ]
      		)
      			
      	def work(self , input_items , output_items ):
      		x = input_items[0] # Senial de entrada .
      		y0 = output_items[0] # Senial acumulada
      		y0[:] = np.cumsum(x)
      		#y0[:]= len(x)
      		return len(y0)
  states: {state: disabled}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):

      	def __init__(self): # only default arguments here
      		gr.sync_block.__init__(
      			self,
      			name="e_Diff", # will show up in GRC
      			in_sig=[np.float32],
      			out_sig=[np.float32]
      		)
      		self.acum_anterior=0
      		
      	def work(self , input_items , output_items ):
      		x=input_items[0] # Senial de entrada .
      		y0=output_items[0] # Senial acumulada diferencial
      		
      		N=len(x)
      		diff=np.cumsum(x)-self.acum_anterior
      		self.acum_anterior = diff[N -1]
      		y0[:]=diff
      		return len(y0)
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk (gr.sync_block ):

      	def __init__ ( self ): # only default arguments here
      		gr.sync_block.__init__(
      			self,
      			name =" Promedios_de_tiempos ", # will show up in GRC
      			in_sig =[ np.float32 ],
      			out_sig =[ np.float32 ,np.float32 ,np.float32 ,np.float32 ,np.float32 ]
      		)
      		self.acum_anterior = 0
      		self.Ntotales = 0
      		self.acum_anterior1 = 0
      		self.acum_anterior2 = 0

      	def work (self , input_items , output_items ):
      		x = input_items[0] # Senial de entrada .
      		y0 = output_items[0] # Promedio de la senial
      		y1 = output_items[1] # Media de la senial
      		y2 = output_items[2] # RMS de la senial
      		y3 = output_items[3] # Potencia promedio de la senial
      		y4 = output_items[4] # Desviacion estandar de la senial

      		# Calculo del promedio
      		N = len(x)
      		self.Ntotales = self.Ntotales + N
      		acumulado = self.acum_anterior + np.cumsum(x)
      		self.acum_anterior = acumulado[N -1]	
      		y0[:]= acumulado/self.Ntotales

      		# Calculo de la media cuadratica
      		x2=np.multiply(x,x)
      		acumulado1 = self.acum_anterior1 + np.cumsum(x2)
      		self.acum_anterior1 = acumulado1[N -1]
      		y1[:] = acumulado1/self.Ntotales

      		# Calculo de la RMS
      		y2[:] = np.sqrt(y1)
      	
      		# Calculo de la potencia promedio
      		y3[:] = np.multiply(y2 ,y2)
      	
      		# Calculo de la desviacion estandar
      		x3 = np.multiply(x-y0 ,x-y0)
      		acumulado2 = self.acum_anterior2 + np.cumsum(x3)
      		self.acum_anterior2 = acumulado2[N -1]
      		y4[:] = np.sqrt( acumulado2 / self.Ntotales )
      	
      		return len (y0)
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"Media acum"'
    max: '8'
    min: '0'
    name: '"Media"'
    type: float
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"Media acum"'
    max: '8'
    min: '0'
    name: '"Media Cuadratica"'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"RMS"'
    name: '"RMS"'
    type: float
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"Potencia Promedio"'
    name: '"Potencia Promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: '"Desviaciòn estandar"'
    name: '"Desviaciòn estandar"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Sin ruido"'
    size: '1024'
    srate: '64000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Con ruido"'
    size: '1024'
    srate: '64000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Filtrado"'
    size: '1024'
    srate: '64000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"ruido"'
    size: '1024'
    srate: '64000'
    type: float
  states: {}

connections:
- [analog_sig_source_x_1_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_1_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_add_xx_0, '0', epy_block_0_0, '0']
- [blocks_add_xx_0, '0', epy_block_1_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0_0, '0', epy_block_1_0, '0']
- [epy_block_0_0, '0', epy_block_2, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [epy_block_1_0, '0', epy_block_2, '0']
- [epy_block_1_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [epy_block_2, '0', qtgui_number_sink_0_1, '0']
- [epy_block_2, '1', qtgui_number_sink_0_2, '0']
- [epy_block_2, '2', qtgui_number_sink_2, '0']
- [epy_block_2, '3', qtgui_number_sink_3, '0']
- [epy_block_2, '4', qtgui_number_sink_4, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
